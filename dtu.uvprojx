# Keil uVision project dtu.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dtu
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\config;.\lw_oopc_v1.2;.\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./: main.c
  group communcation
    ./subsystem/communication/: subsys_commu.h Thread_Commu.c module_tcp.c module_tcp.h
  group config
    ./config/: config_hardware.h config_hadrdware.c
  group include
    ./include/: err_head.h
software components: CMSIS:CORE 4.2.0, CMSIS:RTOS:Keil RTX 4.79.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
